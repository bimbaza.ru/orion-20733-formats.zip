Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:16+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-BC2-B-58
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-BC2-B-58 Цветочница ОЦ-2 · база — серый бетон
In: Площадка
Description: Изделие бетонное благоустройства. Цветочница ОЦ-2 · база — серый бетон; Classification: 59.1.15.01-1076 Скамья (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-BC2-B-58; ModelReference: Цветочница ОЦ-2 · база — серый бетон; ProductionYear: 2026; ArticleNumber: ZSK-BC2-B-58
ORION_Изделие - Артикул: ZSK-BC2-B-58; Артикул прежний: SD-BC2-B-58; Наименование: Цветочница ОЦ-2 · база — серый бетон; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 750×375×250 мм; Материал: Бетон; Цена: 12 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20733; Код КСИ: CPr>EDD070; Класс КСИ: Скамья; Коды КСР: 59.1.15.01-1076 … 59.1.15.02-0539
ADSK - ADSK_Наименование: Цветочница ОЦ-2 · база — серый бетон; ADSK_Марка: ZSK-BC2-B-58; ADSK_Код изделия: 59.1.15.01-1076; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20733
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD070; ZSK_Артикул_прежний: SD-BC2-B-58
Qto_ORION - Длина: 750 mm; Ширина: 375 mm; Высота: 250 mm
